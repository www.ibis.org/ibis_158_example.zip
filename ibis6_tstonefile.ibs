[IBIS Ver]   6.0
[Disclaimer] THESE IBIS MODELS ARE PROVIDED "AS IS" WITH NO
   WARRANTY WHATSOEVER
[File Name]   ibis6_tstonefile.ibs
[Date] Oct 19 2016
[File Rev]   1.0
[Source]  Me
[Notes]
   This model provides a portable ideal TX/RX buffer using [External Model] syntax.
[Copyright]
   No Copyright
[Component] ibis6_tstonefile
[Manufacturer]  None
[Package]
R_pkg   0.001m  NA NA
L_pkg   0.001nH NA NA
C_pkg   0.001pF NA NA
[Pin] signal_name   model_name   R_pin   L_pin   C_pin
1p   ods_tx_p   ods_tx   NA   NA   NA
1n   ods_tx_n   ods_tx   NA   NA   NA
2p   ods_rx_p   ods_rx   NA   NA   NA
2n   ods_rx_n   ods_rx   NA   NA   NA
[Diff Pin] inv_pin   vdiff  tdelay_typ  tdelay_min  tdelay_max
1p   1n   0.0   NA   NA   NA
2p   2n   0.0   NA   NA   NA
|   MODEL ods_tx
[Model] ods_tx
Model_type  Output_diff
Polarity   Non-Inverting
Enable   Active-High
Cref_diff  = 1p
Rref_diff  = 50
Vmeas   = 0.25
[Temperature Range]  25 100 0
[Voltage Range] 1.0  1.0  1.0
[Algorithmic Model]
Executable Windows_CL_32   ibis6_tstonefile_tx.win32.dll   ibis6_tstonefile_tx.ami
Executable Windows_CL_64   ibis6_tstonefile_tx.win64.dll   ibis6_tstonefile_tx.ami
Executable Linux_GCC_32   ibis6_tstonefile_tx.linux32.so   ibis6_tstonefile_tx.ami
Executable Linux_GCC_64   ibis6_tstonefile_tx.linux64.so   ibis6_tstonefile_tx.ami
[End Algorithmic Model]
[Ramp]
dV/dt_r .3/1p .3/1p .3/1p
dV/dt_f .3/10p .3/1p .3/1p
[External Model]
Language IBIS-ISS
| Corner  corner_name  file_name   circuit_name (.subckt name)
Corner   Typ   tx_ods.mod   tx_ods
Parameters Tstonefile   = ibis6_tstonefile_tx.ami(My_AMI_Tx(Model_Specific(Tstonefile)))
Parameters Tx_R   = ibis6_tstonefile_tx.ami(My_AMI_Tx(Model_Specific(Tx_R)))
Converter_Parameters Tx_V = ibis6_tstonefile_tx.ami(My_AMI_Tx(Model_Specific(Tx_V)))
Ports my_driveP my_driveN A_signal_pos  A_signal_neg
| D_to_A d_port   port1   port2   vlow   vhigh   trise   tfall   corner_name  polarity
D_to_A   D_drive  my_driveP   A_gnd   0.   Tx_V   1e-12   1e-12   Typ   Non-Inverting
D_to_A   D_drive  my_driveN   A_gnd   0.   Tx_V   1e-12   1e-12   Typ   Inverting
[End External Model]
|   MODEL ods_rx
[Model] ods_rx
Model_type  Input_diff
Polarity   Non-Inverting
Enable   Active-High
[Temperature Range]  25 100 0
[Voltage Range] 1.0  1.0  1.0
[Algorithmic Model]
Executable Windows_CL_32   ibis6_tstonefile_rx.win32.dll   ibis6_tstonefile_rx.ami
Executable Windows_CL_64   ibis6_tstonefile_rx.win64.dll   ibis6_tstonefile_rx.ami
Executable Linux_GCC_32   ibis6_tstonefile_rx.linux32.so   ibis6_tstonefile_rx.ami
Executable Linux_GCC_64   ibis6_tstonefile_rx.linux64.so   ibis6_tstonefile_rx.ami
[End Algorithmic Model]
[External Model]
Language IBIS-ISS
| Corner  corner_name  file_name   circuit_name (.subckt name)
Corner   Typ   rx_ods.mod   rx_ods
Parameters Tstonefile = ibis6_tstonefile_rx.ami(My_AMI_Rx(Model_Specific(Tstonefile)))
Parameters Rx_R   = ibis6_tstonefile_rx.ami(My_AMI_Rx(Model_Specific(Rx_R)))
Ports A_signal_pos  A_signal_neg my_receive_pos my_receive_neg
A_to_D D_receive my_receive_pos my_receive_neg -0.01 0.01 Typ
[End External Model]
| Models and submodels in the file (2): ods_tx (Output_diff), ods_rx (Input_diff)
